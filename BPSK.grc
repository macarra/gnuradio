options:
  parameters:
    generate_options: qt_gui
    id: BPSK
    output_language: python
    title: BPSK Modulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'False'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '4'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0xc1'
    seed: '0x7F'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '16000'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_0, '0', digital_scrambler_bb_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [digital_psk_mod_0, '0', blocks_throttle_0, '0']
- [digital_scrambler_bb_0, '0', digital_psk_mod_0, '0']

metadata:
  file_format: 1
