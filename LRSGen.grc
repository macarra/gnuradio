options:
  parameters:
    generate_options: qt_gui
    id: lrsgen
    output_language: python
    title: LRSGenerator
  states: {}

blocks:
- name: num_bytes
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lrsout
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_bytes
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '6'
    mask: '0x3'
    seed: '0x7f'
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_null_source_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_head_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
