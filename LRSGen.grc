options:
  parameters:
    generate_options: qt_gui
    id: lrsgen
    output_language: python
    title: LRSGenerator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lrsout
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0xb'
    seed: '0x7f'
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_null_source_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
